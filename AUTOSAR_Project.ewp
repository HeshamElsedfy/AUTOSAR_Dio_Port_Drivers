# IAR project AUTOSAR_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AUTOSAR_Project.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group APP
    ./: App.c App.h main.c
  group BSW/ECUAL/BUTTON
    ./: Button.c Button.h
  group BSW/ECUAL/LED
    ./: Led.c Led.h
  group BSW/MCAL/DIO
    ./: Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h
  group BSW/MCAL/GPT
    ./: Gpt.c Gpt.h
  group BSW/MCAL/PORT
    ./: Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h
  group BSW/SERVICE
    ./: Det.c Det.h
  group LIB
    ./: Common_Macros.h Compiler.h cstartup_M.c Platform_Types.h Std_Types.h
  group OS
    ./: Os.c Os.h
